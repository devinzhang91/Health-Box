# Keil uVision project test01.uvproj, settings and files
target stm32f103_test (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test01 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries;..\STM32F10x_FWLib\inc;..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\TIMER;..\HARDWARE\CAMER;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\KEY;..\HARDWARE\DMA;..\USB\CONFIG;..\USB\LIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UESR
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAPTURE/: capture.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/ADC/: adc1.c adc2.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group USBLIB
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBCONFIG
    ../USB/CONFIG/: hw_config.c usb_endp.c usb_istr.c usb_pwr.c usb_desc.c usb_prop.c
